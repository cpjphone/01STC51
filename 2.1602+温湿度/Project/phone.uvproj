# Keil uVision project phone.uvproj, settings and files
target STC51 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: phone +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Source\BSP;..\Source\BSP\Interrupt;..\Source\BSP\LCD1602;..\Source\BSP\LED;..\Source\BSP\DHT11
  group APP
    ../Source/APP/: App.c
  group BSP
    ../Source/BSP/: BSP.c
    ../Source/BSP/LCD1602/: LCD_1602.c
    ../Source/BSP/DHT11/: dht11.c
  group DOC
    ../Doc/: readme.txt
