# Keil uVision project 双机通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 双机通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 双机通信
    ./: 从机.c
