# Keil uVision project Hardwork.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Hardwork +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\IIC_Drive;.\24C02;.\ModuleDrive
  group Source Group 1
    ./: Hardwork.c
    ./IIC_Drive/: I2C.c
    ./24C02/: 2402.c
    ./ModuleDrive/: 18B20Drive.c
