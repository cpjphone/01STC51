# Keil uVision project LCD12864 Calendar.uvproj, settings and files
target LCD12864 Calendar (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD12864 Calendar +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include;..\Main;..\UserDriver\AlarmClock;..\UserDriver\DisplayTime;..\UserDriver\DS18B20;..\UserDriver\DS1302;..\UserDriver\Font;..\UserDriver\IR;..\UserDriver\KeyPro;..\UserDriver\LCD12864;..\UserDriver\Lunar
  group User
    ../Main/: Main.c
  group UserDriver
    ../UserDriver/LCD12864/: LCD12864.c
    ../UserDriver/DisplayTime/: DisplayTime.c
    ../UserDriver/DS1302/: DS1302.c
    ../UserDriver/DS18B20/: DS18B20.c
    ../UserDriver/KeyPro/: KeyPro.c
    ../UserDriver/Lunar/: Lunar.c
    ../UserDriver/AlarmClock/: AlarmClock.c
    ../UserDriver/Font/: Font.c
    ../UserDriver/IR/: IR.c
