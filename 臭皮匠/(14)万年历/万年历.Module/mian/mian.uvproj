# Keil uVision project mian.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mian +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive\LCD1602_Drive;..\Drive\DS1302_Drive
  group project
    ./: main.c
  group LCD1602_Drive
    ../Drive/LCD1602_Drive/: LCD1602_Drive.c
  group DS11302_Drive
    ../Drive/DS1302_Drive/: DS1302_y.c
