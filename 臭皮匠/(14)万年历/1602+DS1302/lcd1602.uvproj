# Keil uVision project lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ModuleDrive
  group Source Group 1
    ./: lcd1602.c
    ../ModuleDrive/: 18B20Drive.c
