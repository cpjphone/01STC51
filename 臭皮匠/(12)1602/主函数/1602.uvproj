# Keil uVision project 1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\LCD1602_Drive
  group Source Group 1
    ./: shizhong.c
    ../LCD1602_Drive/: LCD1602_Drive.c
