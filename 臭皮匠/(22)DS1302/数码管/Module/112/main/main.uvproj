# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive\DS1302_Drive
  group Source Group 1
    ./: main.c
  group Drive
    ../Drive/DS1302_Drive/: DS1302_y.c
