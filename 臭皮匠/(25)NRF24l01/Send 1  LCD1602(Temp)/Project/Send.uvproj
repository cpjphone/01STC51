# Keil uVision project Send.uvproj, settings and files
target Send (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Send +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include;..\Main;..\UserDriver\NRF24L01;..\UserDriver\Delay;..\UserDriver\Display;..\UserDriver\DS18B20;..\UserDriver\LCD1602
  group User
    ../Main/: Main.c
  group UserDriver
    ../UserDriver/NRF24L01/: NRF24L01.c
    ../UserDriver/LCD1602/: LCD1602.c
    ../UserDriver/Display/: Display.c
    ../UserDriver/DS18B20/: DS18B20.c
    ../UserDriver/Delay/: Delay.c
