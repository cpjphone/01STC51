# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive\LCD1602_Drive;..\Drive\ModuleDrive
  group project
    ./: main.c
  group Drive
    ../Drive/LCD1602_Drive/: LCD1602_Drive.c
    ../Drive/ModuleDrive/: 18B20Drive.c
