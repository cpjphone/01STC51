# Keil uVision project 18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ModuleDrive
  group Project
    ../ModuleDrive/: 18B20Drive.c
    ./: 18B20.c
