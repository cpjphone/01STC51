# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\LCD12864
  group Source Group 1
    ../LCD12864/: LCD12864.c
    ./: main.c
