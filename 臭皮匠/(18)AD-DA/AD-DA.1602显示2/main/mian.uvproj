# Keil uVision project mian.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mian +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\IIC_Drive;..\LCD1602_Drive;..\PCF8591Drive
  group Source Group 1
    ./: main.c
    ../IIC_Drive/: I2C.c
    ../LCD1602_Drive/: LCD1602_Drive.c
    ../PCF8591Drive/: PCF8591Drive.c
