# Keil uVision project mian.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mian +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drive\IIC_Drive;..\Drive\LCD1602_Drive;..\Drive\PCF8591_Drive
  group Source Group 1
    ./: main.c
    ../Drive/IIC_Drive/: I2C.c
    ../Drive/PCF8591_Drive/: PCF8591_Drive.c
