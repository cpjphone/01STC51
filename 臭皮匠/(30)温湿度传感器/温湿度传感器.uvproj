# Keil uVision project 温湿度传感器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温湿度传感器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 温湿度传感器
    ./: 温湿度传感器.c 1602.c main.c
